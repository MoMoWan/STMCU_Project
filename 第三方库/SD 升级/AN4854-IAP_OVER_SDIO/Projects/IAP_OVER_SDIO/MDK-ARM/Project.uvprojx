# Keil uVision project Project.uvprojx, settings and files
target STM32072B_EVAL (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F072VB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32072B_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F072xB,USE_HAL_DRIVER,USE_STM32072B_EVAL
  c misc: --C99
  c include: ../Inc;../../../Drivers/CMSIS/Devices/ST/STM32F0xx/Include;../../../Drivers/STM32F0xx_HAL_Driver/Inc;../../../Drivers/CMSIS/Include;../../../Drivers/BSP/STM32072B_EVAL;../../../Drivers/BSP/Components/Common;../../../Middlewares/Third_Party/FatFs/src;../../../Middlewares/Third_Party/FatFs/src/drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Doc
    ../: readme.txt
  group Drivers/STM32F0xx_HAL_Driver
    ../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_dma.c stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart.c stm32f0xx_hal_spi.c stm32f0xx_hal_flash.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_i2c.c
  group Drivers/BSP/STM32L476G_EVAL
    ../../../Drivers/BSP/STM32L476G_EVAL/: stm32l476g_eval_lcd.c stm32l476g_eval_sd.c stm32l476g_eval.c stm32l476g_eval_io.c
  group Drivers/BSP/STM32F072B_EVAL
    ../../../Drivers/BSP/STM32072B_EVAL/: stm32072b_eval_lcd.c stm32072b_eval.c stm32072b_eval_sd.c
  group Middlewares/FatFs/Drivers
    ../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c system_stm32f0xx.c
  group Example/User
    ../Src/: memory_card.c stm32l4xx_it.c command.c stm32l4xx_flash_if.c stm32f0xx_it.c stm32f0xx_flash_if.c main.c
  group Middlewares/FatFs/Options
    ../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_crc.c stm32l4xx_hal_sram.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal.c stm32l4xx_ll_fmc.c stm32l4xx_hal_sd.c stm32l4xx_hal_pwr.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_flash.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_gpio.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_pwr_ex.c
  group Example/MDK-ARM
    ./: startup_stm32f072xb.s startup_stm32l476xx.s
  group Middlewares/FatFs/Core
    ../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Drivers/BSP/Components
    ../../../Drivers/BSP/Components/spfd5408/: spfd5408.c
    ../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
    ../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
    ../../../Drivers/BSP/Components/hx8347g/: hx8347g.c
    ../../../Drivers/BSP/Components/stlm75/: stlm75.c
    ../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
target STM32L476G_EVAL (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L476ZETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L476G_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,USE_STM32L476G_EVAL_REVB,USE_IOEXPANDER
  c misc: --C99
  c include: ../Inc;../../../Drivers/CMSIS/Devices/ST/STM32L4xx/Include;../../../Drivers/CMSIS/Include;../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../Drivers/BSP/STM32L476G_EVAL;../../../Drivers/BSP/Components/Common;../../../Middlewares/Third_Party/FatFs/src;../../../Middlewares/Third_Party/FatFs/src/drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
software components: CMSIS:CORE 4.3.0
